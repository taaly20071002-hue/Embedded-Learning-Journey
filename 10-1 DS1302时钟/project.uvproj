# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c LCD1602.h LCD1602.c DS1302.c DS1302.c.bak DS1302.c.bak2 DS1302.c.bak3 DS1302.h DS1302.h.bak main.LST
